# Keil uVision project pro.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: pro +hex
  BeforeMake: cmd.exe /C "D:\ti\mspm0_sdk_2_05_00_05\tools\keil\syscfg.bat   'D:\OneDrive\Desktop\_storage_\Project-or-hardware-information\normal\ti\ti_mspm0g3507_car\syscfg'  pro.syscfg"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\driverlib;..\driverlib\m0p;..\driverlib\m0p\sysctl;..\syscfg;..\mine\inc;..\Source\include;..\Source\portable\GCC\ARM_CM0;..\mine\mix\lqx_btns\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: .\driverlib.a
  group start
    ./: startup_mspm0g350x_uvision.s
  group lib
    ../driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ../driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group mine/src
    ../mine/src/: main.c delay.c uart.c hash_cmd.c pid_ctrl.c hmi.c
  group ti_config
    ../syscfg/: pro.syscfg ti_msp_dl_config.c
  group lcd
    ../mine/src/: GUI.c Lcd_Driver.c
  group drv
    ../mine/src/: motor.c gray_scale_sensor.c
    ../mine/mix/lqx_btns/src/: lqx_btns.c lqx_btns_port.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
